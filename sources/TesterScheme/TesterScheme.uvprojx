# Keil uVision project TesterScheme.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ElectricityMeter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --cpp
  c include: .\src;..\common\Hardware\HAL;..\common\GD32F30x_Library\Firmware\GD32F30x_standard_peripheral\Include;..\common\GD32F30x_Library\Firmware\CMSIS;..\common\GD32F30x_Library\Firmware\CMSIS\GD\GD32F30x\Include;..\common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group GD32F30x
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Include/: gd32f30x_gpio.h gd32f30x_rcu.h gd32f30x_adc.h gd32f30x_dma.h gd32f30x_timer.h gd32f30x_misc.h gd32f30x_fwdgt.h
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_i2c.c gd32f30x_adc.c gd32f30x_dma.c gd32f30x_timer.c gd32f30x_misc.c gd32f30x_fmc.c gd32f30x_usart.c gd32f30x_spi.c gd32f30x_wwdgt.c gd32f30x_fwdgt.c
  group src
    ./src/: defines.h Device.h Device.cpp main.cpp
    ../common/: common_defines.h Globals.cpp Globals.h
  group Hardware
    ../common/Hardware/: Timer.cpp Timer.h
    ./src/Hardware/: Bootloader.cpp Bootloader.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32f30x_hd.s system_gd32f30x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL_ROM.cpp
    ../common/Hardware/HAL/: HAL_PINS.cpp HAL_PINS.h systick.c HAL_IT.cpp HAL_USART.cpp HAL.h gd32f30x_libopt.h systick.h HAL.cpp HAL_ADC.cpp HAL_FWDGT.cpp HAL_I2C.cpp HAL_SPI2.cpp HAL_PINS_GP.cpp
  group Display
    ./src/Display/: Console.cpp Console.h Display.cpp Display.h SSD1306.cpp SSD1306.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font8.inc font10_7.inc
  group Measurer
    ./src/Measurer/: Averager.h Calculator.cpp Contactors.cpp Contactors.h Measurer.cpp Measurer.h
  group Modem
    ./src/Modem/: SIM800.cpp Modem.cpp Modem.h Parser.cpp Parser.h SIM800.h SIM800_transmit.cpp
  group Modem/MQTT
    ./src/Modem/MQTT/: MQTT.cpp MQTT.h Sender.cpp Sender.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h
  group Storage
    ./src/Storage/: Storage.cpp Storage.h
  group Utils
    ../common/Utils/: Buffer.h Math.h Log.cpp Log.h Debug.cpp Debug.h String.cpp String.h
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: as above
  output: PKS-Test-Scheme +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --cpp
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
