# Keil uVision project Loader.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ElectricityMeter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --cpp
  c include: .\src;.\src\Hardware\HAL;..\common\GD32F30x_Library\Firmware\GD32F30x_standard_peripheral\Include;..\common\GD32F30x_Library\Firmware\CMSIS;..\common\GD32F30x_Library\Firmware\CMSIS\GD\GD32F30x\Include;..\common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group GD32F30x
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Include/: gd32f30x_gpio.h gd32f30x_rcu.h gd32f30x_adc.h gd32f30x_dma.h gd32f30x_timer.h gd32f30x_misc.h
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_i2c.c gd32f30x_adc.c gd32f30x_dma.c gd32f30x_timer.c gd32f30x_misc.c gd32f30x_fmc.c gd32f30x_usart.c
  group src
    ./src/: defines.h main.cpp Loader.cpp Loader.h Log.cpp Log.h Application.cpp Application.h
    ../common/: common_defines.h
  group Hardware
    ../common/Hardware/: Timer.cpp Timer.h
    ./src/Hardware/: Programmer.cpp Programmer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32f30x_hd.s system_gd32f30x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: gd32f30x_libopt.h HAL.h systick.c systick.h HAL.cpp HAL_IT.cpp HAL_ROM.cpp HAL_USART.cpp
    ../common/Hardware/HAL/: HAL_PINS.cpp HAL_PINS.h
  group Modem
    ./src/Modem/: Modem.cpp Modem.h SIM800.cpp Updater.cpp Updater.h ReaderFTP.cpp ReaderFTP.h SIM800.h
    ../common/Modem/: Parser.h Parser.cpp
  group Utils
    ../common/Utils/: Math.h
