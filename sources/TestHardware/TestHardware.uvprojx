# Keil uVision project TestHardware.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NFC-Reader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F303xC, __cplusplus
  c misc: --cpp
  c include: .\src;.\src\Hardware\HAL;..\common\STM32Cube_F3\Drivers\STM32F3xx_HAL_Driver\Inc;..\common\STM32Cube_F3\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\common\STM32Cube_F3\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STM32F3
    ../common/STM32Cube_F3/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_pwr.c
  group src
    ./src/: main.cpp defines.h Device.cpp Device.h defines.cpp Log.cpp Log.h Test.cpp Test.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f303xc.s system_stm32f3xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.cpp HAL.h HAL_IT.cpp HAL_ADC.cpp HAL_PINS.cpp HAL_PINS.h stm32f3xx_hal_conf.h
  group Hardware/Modules/SIM800C
    ./src/Hardware/Modules/SIM800C/: SIM800C.cpp SIM800C.h
  group Hardware/Modules/SSD1306
    ./src/Hardware/Modules/SSD1306/: SSD1306.cpp SSD1306.h
  group Hardware/Modules/ZMPT101
    ./src/Hardware/Modules/ZMPT101/: ZMPT101.cpp ZMPT101.h
  group Calculator
    ./src/Calculator/: Calculator.cpp Calculator.h
  group FlashDisk
    ./src/FlashDisk/: FlashDisk.cpp FlashDisk.h
  group Display
    ./src/Display/: Display.cpp Display.h
  group Measurer
    ./src/Measurer/: Measurer.cpp Measurer.h
  group Modem
    ./src/Modem/: Modem.cpp Modem.h
  group Utils
    ./src/Utils/: Buffer.h
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: as above
  output: NFC-777-2 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F303xC, __cplusplus
  c misc: --cpp
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
