# Keil uVision project Device.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ElectricityMeter +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects-Debug\ElectricityMeter.axf --output Meter.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --cpp
  c include: .\src;.\src\Hardware\HAL;..\common\GD32F30x_Library\Firmware\GD32F30x_standard_peripheral\Include;..\common\GD32F30x_Library\Firmware\CMSIS;..\common\GD32F30x_Library\Firmware\CMSIS\GD\GD32F30x\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Device.sct
  group GD32F30x
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Include/: gd32f30x_gpio.h gd32f30x_rcu.h gd32f30x_adc.h gd32f30x_dma.h gd32f30x_timer.h gd32f30x_misc.h
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_i2c.c gd32f30x_adc.c gd32f30x_dma.c gd32f30x_timer.c gd32f30x_misc.c gd32f30x_fmc.c gd32f30x_usart.c gd32f30x_spi.c gd32f30x_wwdgt.c
  group src
    ./src/: defines.h Device.h Device.cpp main.cpp Log.cpp Log.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32f30x_hd.s system_gd32f30x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: gd32f30x_libopt.h HAL.h systick.c systick.h HAL.cpp HAL_ADC.cpp HAL_I2C.cpp HAL_IT.cpp HAL_ROM.cpp HAL_PINS.cpp HAL_PINS.h HAL_USART.cpp HAL_SPI.cpp HAL_RTC.cpp HAL_WWDGT.cpp
  group Hardware/Modules/SSD1306
    ./src/Hardware/Modules/SSD1306/: SSD1306.h SSD1306.cpp
  group Hardware/Modules/M25P80
    ./src/Hardware/Modules/M25P80/: M25P80.cpp M25P80.h
  group Display
    ./src/Display/: Display.h Display.cpp
  group Display/Font
    ./src/Display/Font/: font5.inc font8.inc Font.h font10_7.inc Font.cpp
  group FlashDisk
    ./src/FlashDisk/: FlashDisk.h FlashDisk.cpp
  group Measurer
    ./src/Measurer/: Measurer.h Calculator.cpp Measurer.cpp Contactors.cpp Contactors.h
  group Modem
    ./src/Modem/: Modem.h Modem.cpp Parser.cpp Parser.h MQTT.cpp SIM800.cpp
  group Utils
    ./src/Utils/: Buffer.cpp Buffer.h Math.h String.cpp String.h
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: as above
  output: NFC-777-2 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, GD32F30X_HD
  c misc: --cpp
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
